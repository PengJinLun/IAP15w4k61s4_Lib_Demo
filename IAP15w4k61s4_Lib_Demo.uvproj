# Keil uVision project IAP15w4k61s4_Lib_Demo.uvproj, settings and files
target IAP15w4k61s4_Lib_Demo (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: IAP15w4k61s4_Lib_Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src\lib;.\src\app;.\src\demo;.\src\main;.\src\drv;.\src\app;.\src\common
  group demo
    ./src/demo/: led_demo.c timer_demo.c adc_demo.c adc_bandgap_demo.c uart1_demo.c ds18b20_demo.c
  group lib
    ./src/lib/: ADC.c delay.c EEPROM.c Exti.c GPIO.c PCA.c Soft_UART.c timer.c USART.C
  group main
    ./src/main/: main.c
  group app
    ./src/app/: temperature_controller.c
  group drv
    ./src/drv/: ds18b20_drv.c
  group common
    ./src/common/: common.c ctype.c
